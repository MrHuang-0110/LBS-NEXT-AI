# Keil uVision project atk_f103.uvprojx, settings and files
target SparkAi (6240000::V6.24::ARMCLANG)
  device: APM32E103RE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,PIKA_CONFIG_ENABLE
  c include: ..\..\Users;..\..\Drivers;..\..\src\driver\bsp;..\..\src\driver\sys;..\..\src\driver\chip;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Middlewares\usb\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Middlewares\usb\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\usb\USB_HAL;..\..\python\pikascript-core;..\..\python\pikascript-api;..\..\python\pikascript-lib\PikaStdLib;..\..\application\beep;..\..\application\motor;..\..\application\blue;..\..\application\color;..\..\application\touch;..\..\application\ultrasion;..\..\Middlewares\ymodem;..\..\Middlewares\stubs;..\..\src\middleware;..\..\src\protocol;..\..\src\business\devices;..\..\src\business\devices\matrix;..\..\src\business\pika;..\..\src\business\pika\ExternLib;..\..\src\business\app
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group business/devices
    ../../src/business/devices/: beep.c motor.c blue.c color.c touch.c ultrasion.c
  group WillAi/BSP
    ../../src/driver/bsp/: led.c drv_led.c drv_flash_storage.c btim.c key.c stmflash.c adc.c drv_ir_reflect.c iic.c spi.c wdg.c
  group User
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group business/app
    ../../src/business/app/: main.c app_cmd.c app_boot_param.c stm32f1xx_it.c
  group business/pika
    ../../src/business/pika/: app_pika_runtime.c app_pika_script_flash.c pika_config.c
  group Drivers/SYSTEM
    ../../src/driver/sys/: sys.c delay.c usart.c
  group src/driver/chip
    ../../src/driver/chip/: tm1640.c w25q80.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c
  group WillAi/Middle
    ../../src/middleware/: event_manager.c malloc.c lbsfilemanager.c device_pool.c drv_mem.c drv_comm.c bat_manager.c
    ../../src/protocol/: frame.c cmd.c at.c monitor.c json-maker.c ymodem.c
    ../../Middlewares/stubs/: matrix_port_stub.c _matrix_stub.c
  group Middle/USB_CORE
    ../../Middlewares/usb/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middle/USB_CLASS
    ../../Middlewares/usb/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middle/USB_APP
    ../../src/middleware/: usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Middle/USB_HAL
    ../../Middlewares/usb/USB_HAL/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group pikascript-core
    ../../python/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaCompiler.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group pikascript-api
    ../../python/pikascript-api/: __asset_pikaModules_py_a.c __pikaBinding.c pikaScript.c
  group pikascript-lib
    ../../python/pikascript-lib/PikaStdLib/: PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_Dict.c PikaStdData_FILEIO.c PikaStdData_List.c PikaStdData_String.c PikaStdData_Tuple.c PikaStdData_Utils.c PikaStdLib_MemChecker.c PikaStdLib_RangeObj.c PikaStdLib_StringObj.c PikaStdLib_SysObj.c PikaStdTask_Task.c
    ../../src/business/pika/ExternLib/: _motor.c _os.c _color.c _touch.c _ultrasion.c _key.c _beep.c
    ../../python/pikascript-lib/random/: _random.c
    ../../python/pikascript-lib/math/: _math.c
  group Readme
    ../../: readme.txt
